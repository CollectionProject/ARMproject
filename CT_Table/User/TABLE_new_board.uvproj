# Keil uVision project TABLE_new_board.uvproj, settings and files
target TABLE_new_board (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: CT64_Table +hex
  AfterMake: D:\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o ../obj/bin/CT64_Table.bin ../obj/CT64_Table.axf
  AfterMake: D:\Keil\ARM\ARMCC\bin\fhadd.exe TABLE ../obj/bin/CT64_Table.bin
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\BSP;..\BSP\CANopen;..\User
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group BSP
    ../BSP/: spi.c can.c table_gpio.c bsp.c ems_handle.c iwdg.c
    ../BSP/CANopen/: init.c lifegrd.c nmtMaster.c objacces.c objdict.c pdo.c sdo.c sync.c timer.c
  group core
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_can.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_spi.c stm32f4xx_wwdg.c stm32f4xx_sdio.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_iwdg.c stm32f4xx_i2c.c stm32f4xx_fsmc.c stm32f4xx_dma.c stm32f4xx_dac.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_flash.c
  group uCOSII-Core
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOSII-Port
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group uCOSII-Config
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group DOC
    ../: 修改说明.txt
