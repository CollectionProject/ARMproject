# Keil uVision project IAP.uvproj, settings and files
target IAP (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: CAN_IAP_V1_0 +hex
  AfterMake: D:\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o ../obj/bin/CAN_IAP_V1_0.bin ../obj/CAN_IAP_V1_0.axf
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\FWLIB\inc;..\IAP;..\HARDWARE\STMFLASH;..\HARDWARE\CAN
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/CAN/: can.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_flash.c stm32f4xx_can.c stm32f4xx_crc.c
  group IAP
    ../IAP/: iap.c
  group README
    ../: readme.txt
