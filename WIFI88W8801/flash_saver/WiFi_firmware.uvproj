# Keil uVision project WiFi_firmware.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: WiFi_firmware
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: HSE_VALUE=8000000 STM32F40_41xxx USE_STDPERIPH_DRIVER
  c include: .\STM32F4xx_StdPeriph_Driver;.\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c sd8801_uapsta.c
  group STM32F4xx_StdPeriph_Driver
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_crc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
    ./STM32F4xx_StdPeriph_Driver/: system_stm32f4xx.c startup_stm32f40_41xxx.s
