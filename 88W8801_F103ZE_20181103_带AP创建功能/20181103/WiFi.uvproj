# Keil uVision project WiFi.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WiFi +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\lwip-2.0.3\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c common.c WiFi.c WiFi_LowLevel.c wifi_test.c
  group lwip-2.0.3
    ./lwip-2.0.3/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ./lwip-2.0.3/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ./lwip-2.0.3/netif/: ethernet.c ethernetif.c
    ./lwip-2.0.3/apps/httpd/: fs.c httpd.c
    ./lwip-2.0.3/apps/netbiosns/: netbiosns.c
